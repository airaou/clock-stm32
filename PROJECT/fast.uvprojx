# Keil uVision project fast.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: fast +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\HARDWARE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\dht11;..\HARDWARE\keys;..\HARDWARE\music;..\HARDWARE\oled12864;..\HARDWARE\rtc_lse;..\SOFTWARE
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ../USER/: main.c stm32f10x_it.c system_stm32f10x.c
  group SOFTWARE
    ../SOFTWARE/: button.c controls.c progress.c table.c calendar.c text.c alarm.c list.c menu_alr.c menu_options.c menu_calendar.c menu.c menu_other.c menu_game.c game_snaker.c game_mine.c festival.c music_player.c
  group HARDWARE
    ../HARDWARE/dht11/: DHT11.c
    ../HARDWARE/keys/: KEY.c
    ../HARDWARE/music/: music.c tune.c
    ../HARDWARE/oled12864/: font.c oled12864.c oled12864_draw.c
    ../HARDWARE/rtc_lse/: rtc.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_bkp.c stm32f10x_exti.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_tim.c
  group README
    ../: README.txt
